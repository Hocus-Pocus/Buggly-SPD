# Repository Hocus-Pocus/Buggly-SPD

File README.md:

# Buggly-SPD
Programmable engine management for the air cooled VW Dual Port 1600 with Mexican EFI OEM parts. The board is a stripped down, "no frills" variant of the official Speeduino V4.4 board with one particular application in mind. A stock, or relatively stock, air cooled VW dual port 1600 engine being converted to EFI using most of the OEM hardware from the Mexican 1600i, and a 36-1 trigger wheel with a VR CKP sensor. It is designed to use waste spark ignition and injectors paired 1&3, 2&4, fired 2 times alternating over the 720 degree engine cycle. The injector pulse is scheduled to be finished when the intake valve reaches the end of its effective duration. With a firing order of 1-4-3-2, half the fuel is injected on an open intake valve, and the other half is injected on a closed intake valve. This should result in a smoother running engine at all speeds and loads as each cylinder gets the same balanced charge mix. This board connects to the Arduino Mega 2560 and is housed in a Hammond enclosure. It has a power supply for the Mega and does all the low voltage processing. It connects to the Buggly Aux board, also in a Hammond enclosuer that has the high current outputs, fuses, relays and terminal strips for connection to vehicle wiring. Header for a Blutooth module added 1-06-23.

  WORK IN PROGRESS

## KiCad design KiCad files/Buggly SPD.kicad_pcb

Parts:
J1, J2, J7, J8, J11, J12: Conn_01x01; PinHeader_1x01_P2.54mm_Vertical
J3, J5, J9, J10, J13, J17: Conn_01x02; PinHeader_1x02_P2.54mm_Vertical
J4: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J6: Conn_01x07; PinHeader_1x07_P2.54mm_Vertical

Connections:
ADC-Clamp-0: J6.1; also elsewhere on the board
ADC-Clamp-1: J6.2; also elsewhere on the board
ADC-Clamp-2: J6.3; also elsewhere on the board
ADC-Clamp-4: J6.5; also elsewhere on the board
ADC-Clamp-6: J6.7; also elsewhere on the board
GND: J1.1, J4.2, J4.3, J13.1, J13.2; also elsewhere on the board
MCU-A3: J6.4; also elsewhere on the board
MCU-A5: J6.6; also elsewhere on the board
MCU-D0: J17.2; also elsewhere on the board
MCU-D1: J17.1; also elsewhere on the board
MCU-D5: J5.2; also elsewhere on the board
MCU-D6: J5.1; also elsewhere on the board
MCU-D8: J3.2; also elsewhere on the board
MCU-D9: J3.1; also elsewhere on the board
MCU-D19: J7.1; also elsewhere on the board
MCU-D38: J10.1; also elsewhere on the board
MCU-D40: J10.2; also elsewhere on the board
MCU-D45: J11.1; also elsewhere on the board
MCU-D49: J12.1; also elsewhere on the board
RESET: J2.1; also elsewhere on the board
VDD: J4.1, J9.1, J9.2; also elsewhere on the board

Notes on the sheet:
Ign1 control
ASD Relay coil
Ign2 control
Tachometer control
Reset Protection
Inlet Air Temperature input
Cylinder Head Temperature input
Throttle Position input
Exhaust Gas Oxygen input
Battery Voltage input
Manifold Absolute Pressure input
Barometric Pressure input
(Inj1 control)
(PWM Idle control)
(Inj2 control)
Header pin connections to Arduino Mega 2560 header sockets
Crank Position input
(Spare H/C output)
Spare ADC
Bluetooth RX0
Bluetooth TX0

Parts:
C1, C2: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18X7R1H103KNU06; Digikey Part Number 445-174244-1-ND
C3, C4, C9, C10, C11, C12: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18X8R1E104KNU06; Digikey Part Number 445-180563-1-ND
C5, C6, C13, C14, C15, C16: 0.22uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18X8R1E224KRU06; Digikey Part Number 445-180564-1-ND
C7, C8: 47pf; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18NP01H471JNU06; Digikey Part Number 445-180522-1-ND
C17: 0.01uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18X7R1H103KNU06; Digikey Part Number 445-174244-1-ND
IC1: Trig Cond Socket; DIP-8_W7.62mm_Socket
J16: SP721APP; DIP-8_W7.62mm
J18: Conn_01x04; PinSocket_1x04_P2.54mm_Horizontal
R1: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C1001FRP00; Digikey Part Number BC1.00KXCT-ND
R2: 3.9k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C3901FCT00; Digikey Part Number BC3272CT-ND
R3, R4, R9, R10, R11, R12: 470R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C4700FRP00; Digikey Part Number BC3516CT-ND
R5, R6: 51K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C4700FRP00; Digikey Part Number BC3516CT-ND
R7, R8: 2.49k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C2491FRP00; Digikey Part Number BC2.49KXCT-ND
R36: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C4700FRP00; Digikey Part Number BC3516CT-ND
R37: 2.2K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C4700FRP00; Digikey Part Number BC3516CT-ND
U1, U2: MPXH6115_Adapter_Vertical

Connections:
ADC-Clamp-0: C14.1, J16.1, R10.1; also elsewhere on the board
ADC-Clamp-1: C15.1, J16.2, R11.1; also elsewhere on the board
ADC-Clamp-2: C16.1, J16.3, R12.1; also elsewhere on the board
ADC-Clamp-4: C6.1, J16.5, R4.1; also elsewhere on the board
ADC-Clamp-6: C13.1, J16.6, R9.1; also elsewhere on the board
CKP+: IC1.2; also elsewhere on the board
CKP-: IC1.1; also elsewhere on the board
CLT-Sensor: C11.1, R8.1, R11.2; also elsewhere on the board
GND: C17.2, IC1.6, J18.2, R37.1; also elsewhere on the board
IAT-Sensor: C10.1, R7.1, R10.2; also elsewhere on the board
MCU-A3: C7.1, R5.1; also elsewhere on the board
MCU-A5: C8.1, R6.1; also elsewhere on the board
MCU-D0: J18.3; also elsewhere on the board
MCU-D1: R36.2; also elsewhere on the board
MCU-D19: C17.1, IC1.8; also elsewhere on the board
unnamed: C4.1, R1.2, R2.1, R4.2
unnamed: J18.4, R36.1, R37.2
unnamed: R5.2, U1.4
unnamed: R6.2, U2.4
O2-Sensor: C3.1, R3.2; also elsewhere on the board
SigRtn: C1.1, C2.1, C3.2, C4.2, C5.2, C6.2, C7.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, J16.4, R1.1, U1.3, U2.3; also elsewhere on the board
Spare-ADC: C9.1, R9.2; also elsewhere on the board
TPS-Sensor: C12.1, R12.2; also elsewhere on the board
VDD: IC1.5, J18.1; also elsewhere on the board
VDDA: C1.2, C2.2, J16.8, R7.2, R8.2, U1.2, U2.2; also elsewhere on the board

Notes on the sheet:
MAP Sensor
O2 Sensor
Throttle Position Sensor
Inlet Air Temperature Sensor
Coolant Temperature Sensor
Battery reference voltage
Baro Sensor
From Aux board
Note! MAP and Baro sensors need a separate adapter board that uses a 4 pin in line foorprint
CKP input
DIP8 sized socket pair will accept conditioner modules from WTMotronics, JB Perf V2.1, and possibly others that use the MAX9926 chip.
Crank Angle Sensor Conditioner
Spare ADC
IAT
CLT
TPS
BAT
Spare
ADC Clamps
DSD Tech HC-06 Bluetooth module header
Gnd
BT TX
BT RX
RX0
TX0

Parts:
C18, C20: 1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
C19: .01uf; C_Disc_D5.0mm_W2.5mm_P2.50mm
C21: .01uF; C_Disc_D5.0mm_W2.5mm_P2.50mm
Q1: 2N3906; TO-92_Inline_Wide; MPN 2N3906; Digi-Key_PN 2N3906CS-ND
R13, R14, R15, R20, R21, R35: 22R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R16, R24, R25, R26, R28, R29: 100K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R17: 24K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R18: 4.7K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
R19, R27, R30, R31, R32, R33, R34: 1K; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal
U3, U4, U5: IXDNI604PI; DIP-8_W7.62mm
U6: ULN2004AN; DIP-16_W7.62mm; Manufacturer_Part_Number ULN2003AIN‎; Digikey Part Number 296-16971-5-ND

Connections:
D5-control: R35.1; also elsewhere on the board
D6-control: R15.1; also elsewhere on the board
D8-control: R13.1; also elsewhere on the board
D9-control: R14.1; also elsewhere on the board
D38-control: R21.1; also elsewhere on the board
D40-control: R20.1; also elsewhere on the board
D45-control: U6.11 (O6); also elsewhere on the board
D49-control: R18.1, U6.10 (O7)
F5-out: Q1.1 (E), R17.2; also elsewhere on the board
GND: C18.1, C19.1, C20.1, C21.1, R16.1, R24.2, R25.1, R26.2, R28.2, R29.1, U3.3, U4.3, U5.3, U6.8 (GND); also elsewhere on the board
MCU-D5: R16.2, R27.2; also elsewhere on the board
MCU-D6: R26.1, R34.2; also elsewhere on the board
MCU-D8: R28.1, R32.2; also elsewhere on the board
MCU-D9: R29.2, R33.2; also elsewhere on the board
MCU-D38: R25.2, R31.2; also elsewhere on the board
MCU-D40: R24.1, R30.2; also elsewhere on the board
MCU-D45: U6.6 (I6); also elsewhere on the board
MCU-D49: U6.7 (I7); also elsewhere on the board
unnamed: Q1.2 (B), R17.1, R18.2
unnamed: Q1.3 (C), R19.2
unnamed: R13.2, U3.7
unnamed: R14.2, U3.5
unnamed: R15.2, U4.7
unnamed: R20.2, U5.7
unnamed: R21.2, U5.5
unnamed: R27.1, U4.4
unnamed: R30.1, U5.2
unnamed: R31.1, U5.4
unnamed: R32.1, U3.2
unnamed: R33.1, U3.4
unnamed: R34.1, U4.2
unnamed: R35.2, U4.5
Tachometer: R19.1; also elsewhere on the board
VDD: C19.2, C20.2, U5.6; also elsewhere on the board

Notes on the sheet:
(Inj1)
(Inj2)
(PWM Idle)
ASD Relay coil (Fuel Pump) in Aux board
Tachometer circuit in Aux board
Tachometer control
ASD Relay (Fuel Pump) control
(Ign2)
(Ign1)
(500mA sinking max)
High current output drivers control
Low current outputs and control
MCU-D8 (Inj1) Pin default Low, Hi to energise injector, Lo to de-energise injector.
MCU-D9 (Inj2) Pin default Low, Hi to energise injector, Lo to de-energise injector.
MCU-D38 (Ign1) Pin default Low, Hi to energise coil, Lo to de-energise coil.
MCU-D40 (Ign2) Pin default Low, Hi to energise coil, Lo to de-energise coil.
MCU-D45 (ASD Relay)) Pin default Low, Hi to energise relay, Lo to de-energise relay.
MCU-D49 (Tachometer) Pin default Low, Goes Hi after boot sequence. Goes Lo at start of dwell, goes Hi at end of dwell.
(Sinking Transistor PWM Output from ULN2003)
(12 volt square wave signal to tachometer & LED)
Tachometer driver circuit
(Pin defaults low. Goes high after boot sequence, goes low at start of coil dwell, goes Hi after end of coil dwell.)
(AUIRF3205)
(ISL9V3040P3)
(Spare H/C out)

Parts:
C22: 22uF; C_Disc_D7.5mm_W5.0mm_P5.00mm; Manufacturer_Part_Number FA22X7R1E226MRU06; Digikey Part Number 445-180603-1-ND
C23: 10uF; CP_Radial_D5.0mm_P2.00mm; Voltage 50v; Manufacturer_Part_Number EEU-FC1H100L; Digikey Part Number P10316-ND
C24: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Voltage 50v; Manufacturer_Part_Number FA18X8R1E104KNU06; Digikey Part Number 445-180563-1-ND
C25: 0.1uF; C_Disc_D5.0mm_W2.5mm_P2.50mm; Manufacturer_Part_Number FA18X8R1E104KNU06; Digikey Part Number 445-180563-1-ND
C26: 47uF; CP_Radial_D8.0mm_P5.00mm; Manufacturer_Part_Number EEU-FC1H470B; Digikey Part Number P19658CT-ND
D17: 1N5818; D_DO-41_SOD81_P10.16mm_Horizontal
F1: MF-R050; Fuse_BelFuse_0ZRE0100FF_L18.7mm_W5.1mm; Manufacturer_Part_Number 0ZRP0050FF1E; Digikey Part Number 507-2403-ND
J8: 12V Test; PinSocket_1x01_P2.54mm_Vertical
JP1: Jumper_NO_Small; PinHeader_1x02_P2.54mm_Vertical
JP2: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_RoundedPad1.0x1.5mm
R22: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C1002FRP00; Digikey Part Number BC10.0KXCT-ND
R23: 120R; R_Axial_DIN0207_L6.3mm_D2.5mm_P7.62mm_Horizontal; Manufacturer_Part_Number MBA02040C1200FC100; Digikey Part Number BC3453CT-ND
RV1: ERZ-V14D220; RV_Disc_D15.5mm_W4.7mm_P7.5mm
U7: LM2940T-5.0; TO-220-3_Horizontal_TabDown; Manufacturer_Part_Number NCV7805BTG; Digikey Part Number NCV7805BTGOS-ND

Connections:
12V-Raw: D17.2 (A), RV1.1; also elsewhere on the board
GND: C22.2, C23.2, C24.2, C25.2, C26.2, JP2.2 (B), RV1.2, U7.2 (GND); also elsewhere on the board
unnamed: C22.1, JP1.1, R23.1
RESET: JP1.2, R22.1; also elsewhere on the board
SigRtn: JP2.1 (A); also elsewhere on the board
VDD: C25.1, C26.1, F1.2, R22.2, R23.2, U7.3 (VO); also elsewhere on the board
VDDA: F1.1; also elsewhere on the board

Notes on the sheet:
5 Volt Power Regulator
Reset Protection
Refer AVR040 Application Note
12 volt output from Main Relay in Aux board
10V
50V
35V
12 volt test point header socket
Note! SigRtn connects to ground at this point only.

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
Board: 2 copper layers, 120.4 x 100.1 mm, 95 parts (0 on the bottom side), 62 nets.

Other parts of the board:
J8#2: 12V Test; Jumper-Pad
J15: DB25_Male; DSUB-25_Male_Horizontal_P2.77x2.84mm_EdgePinOffset4.94mm_Ho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

Their connections:
12V-Raw: J15.5; also elsewhere on the board
CKP+: J15.14; also elsewhere on the board
CKP-: J15.1; also elsewhere on the board
CLT-Sensor: J15.24; also elsewhere on the board
D5-control: J15.6; also elsewhere on the board
D6-control: J15.17; also elsewhere on the board
D8-control: J15.16; also elsewhere on the board
D9-control: J15.4; also elsewhere on the board
D38-control: J15.3; also elsewhere on the board
D40-control: J15.15; also elsewhere on the board
D45-control: J15.18; also elsewhere on the board
F5-out: J15.19; also elsewhere on the board
GND: J15.7, J15.20; also elsewhere on the board
IAT-Sensor: J15.11; also elsewhere on the board
O2-Sensor: J15.25; also elsewhere on the board
SigRtn: J15.23; also elsewhere on the board
Spare-ADC: J15.13; also elsewhere on the board
TPS-Sensor: J15.12; also elsewhere on the board
Tachometer: J15.2; also elsewhere on the board
VDDA: J15.10; also elsewhere on the board

## Commit log

2022-12-08 Create Git Hold
